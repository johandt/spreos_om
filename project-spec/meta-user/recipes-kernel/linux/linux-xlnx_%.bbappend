SRC_URI += "file://user_2021-08-16-07-29-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

